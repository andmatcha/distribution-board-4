<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\distribution_board_4.ewp</path>
  </project>
  <batchBuild />
</workspace>
